#ifndef STM32F411XE_100MHZ_H
#define STM32F411XE_100MHZ_H

#include "stm32f411xe.h"

// HSE = 25MHz, SCLK = 100MHz, PLL used
static inline void Clock_HSE_100MHz(void) {
  RCC->CR |= RCC_CR_HSEON;
  while (!(RCC->CR & RCC_CR_HSERDY))
    ;

  RCC->APB1ENR |= RCC_APB1ENR_PWREN;

  PWR->CR |= PWR_CR_VOS;
  FLASH->ACR = FLASH_ACR_LATENCY_3WS | FLASH_ACR_PRFTEN | FLASH_ACR_ICEN |
               FLASH_ACR_DCEN;

  RCC->CFGR &= ~RCC_CFGR_HPRE;
  RCC->CFGR |= RCC_CFGR_PPRE1_DIV2;
  RCC->CFGR &= ~RCC_CFGR_PPRE2;

  RCC->PLLCFGR = 0x00000000;
  RCC->PLLCFGR = (25U << RCC_PLLCFGR_PLLM_Pos) |
                 (200U << RCC_PLLCFGR_PLLN_Pos) | (0U << RCC_PLLCFGR_PLLP_Pos) |
                 (4U << RCC_PLLCFGR_PLLQ_Pos) | RCC_PLLCFGR_PLLSRC_HSE;

  RCC->CR |= RCC_CR_PLLON;
  while (!(RCC->CR & RCC_CR_PLLRDY))
    ;

  RCC->CFGR &= ~RCC_CFGR_SW;
  RCC->CFGR |= RCC_CFGR_SW_PLL;

  while ((RCC->CFGR & RCC_CFGR_SWS) != RCC_CFGR_SWS_PLL)
    ;
}

#endif /* STM32F411XE_100MHZ_H */